# Keil uVision project SPI and adc1.uvprojx, settings and files
target SPI and adc1 (ARM-ADS)
  device: STM32F205RBTx STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.9.0
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x801FFFF)  CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: SPI and adc1 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F205xx,USE_HAL_DRIVER,STM32F205xx
  c include: ../Inc;                                          ../Drivers/STM32F2xx_HAL_Driver/Inc;                                          ../Drivers/STM32F2xx_HAL_Driver/Inc/Legacy;                                          ../Drivers/CMSIS/Device/ST/STM32F2xx/Include;                                          ../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f205xx.s
  group Application/User
    ../Src/: main.c stm32f2xx_it.c stm32f2xx_hal_msp.c
  group Drivers/CMSIS
    ../Src/: system_stm32f2xx.c
  group Drivers/STM32F2xx_HAL_Driver
    ../Src/: mpu6050.c
    ../Drivers/STM32F2xx_HAL_Driver/Src/: stm32f2xx_hal_adc.c stm32f2xx_hal_adc_ex.c stm32f2xx_hal.c stm32f2xx_hal_rcc.c stm32f2xx_hal_rcc_ex.c stm32f2xx_hal_cortex.c stm32f2xx_hal_flash.c stm32f2xx_hal_flash_ex.c stm32f2xx_hal_pwr.c stm32f2xx_hal_pwr_ex.c stm32f2xx_hal_gpio.c stm32f2xx_hal_dma.c stm32f2xx_hal_dma_ex.c stm32f2xx_hal_exti.c stm32f2xx_hal_can.c stm32f2xx_hal_i2c.c stm32f2xx_hal_spi.c stm32f2xx_hal_tim.c stm32f2xx_hal_tim_ex.c stm32f2xx_hal_uart.c
software components: CMSIS:CORE 4.3.0
